# Keil uVision project Lenz_USB_FlashTool.uvprojx, settings and files
target Lenz_USB_FlashTool (6190000::V6.19::ARMCLANG)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Lenz_USB_FlashTool +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32G431xx,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../lib/BiSS_C_Master
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Inc/: hw_cfg.h uart.h
    ../Core/Src/: uart.c main.c stm32g4xx_it.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_ll_cordic.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_rcc.c stm32g4xx_ll_usart.c stm32g4xx_ll_spi.c stm32g4xx_ll_pwr.c stm32g4xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group BiSS_C_Master
    ../../lib/BiSS_C_Master/: biss_c_master_hal.c biss_c_master_hal.h biss_c_master.c biss_c_master.h
software components: CMSIS:CORE 6.0.0
